# Keil uVision project stm32g030c8.uvprojx, settings and files
target stm32g030c8 (6160000::V6.16::ARMCLANG)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: stm32g030c8 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32G030xx,USE_HAL_DRIVER
  c include: ../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;..\pikascript\pikascript-core;..\pikascript\pikascript-api;..\pikascript\pikascript-lib\STM32;..\pikascript\pikascript-lib\STM32G030Booter;..\pikascript\pikascript-lib\PikaPiZero
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Booter
    ../pikascript/pikascript-lib/STM32G030Booter/: gpio.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_stm32g0xx.c startup_stm32g030xx.s stm32g030_pika_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dac.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_utils.c
  group pikascript-api
    ../pikascript/pikascript-api/: PikaMain-api.c pikaScript.c PikaStdLib_MemChecker-api.c PikaStdLib_SysObj-api.c PikaStdLib-api.c PikaStdDevice_ADC-api.c PikaStdDevice_GPIO-api.c PikaStdDevice_IIC-api.c PikaStdDevice_PWM-api.c PikaStdDevice_Time-api.c PikaStdDevice_UART-api.c STM32_ADC-api.c STM32_GPIO-api.c STM32_PWM-api.c STM32_Time-api.c STM32_UART-api.c STM32-api.c PikaPiZero_RGB-api.c PikaPiZero-api.c STM32_IIC-api.c PikaPiZero_OLED-api.c PikaPiZero_Point-api.c STM32_lowLevel-api.c
  group pikascript-lib
    ../pikascript/pikascript-lib/PikaStdLib/: PikaStdLib_MemChecker.c PikaStdLib_SysObj.c
    ../pikascript/pikascript-lib/PikaPiZero/: PikaPiZero_RGB.c RGB_ASM.lib oled.c PikaPiZero_OLED.c
    ../pikascript/pikascript-lib/STM32/: STM32_ADC.c STM32_common.c STM32_GPIO.c STM32_PWM.c STM32_Time.c STM32_UART.c STM32_IIC.c
    ../pikascript/pikascript-lib/PikaStdDevice/: PikaStdDeivce_GPIO.c PikaStdDevice_ADC.c PikaStdDevice_IIC.c PikaStdDevice_PWM.c PikaStdDevice_Time.c PikaStdDevice_UART.c
  group pikascript-core
    ../pikascript/pikascript-core/: TinyObj.c PikaObj.c dataStrs.c dataString.c dataMemory.c dataLinkNode.c dataLink.c dataArgs.c dataArg.c BaseObj.c dataQueue.c dataQueueObj.c PikaParser.c PikaVM.c dataStack.c PikaPlatform.c
software components: CMSIS:CORE 5.5.0
